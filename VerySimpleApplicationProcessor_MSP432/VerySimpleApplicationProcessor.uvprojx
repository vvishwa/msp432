# Keil uVision project VerySimpleApplicationProcessor.uvprojx, settings and files
target VerySimpleApplicationProcessor (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.2.1
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VerySimpleApplicationProcessor
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../inc/: CortexM.c Clock.c UART0.c UART1.c AP.c LaunchPad.c GPIO.c
    ./: VerySimpleApplicationProcessor.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
